# Autodesk Inventor assembly: BB3_Pignon_Bas
## iProperties
Created: 2008-11
Part Number: BB3_Pignon_Bas
Document SubType Name: Assembly
Designer: LAIVIER CYRIL
Author: LAIVIER CYRIL
