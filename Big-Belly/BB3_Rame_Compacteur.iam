# Autodesk Inventor assembly: Coulissant_Vertical
## iProperties
Created: 2008-12
Part Number: Coulissant_Vertical
Document SubType Name: Assembly
Designer: LAIVIER CYRIL
Author: LAIVIER CYRIL
