# Autodesk Inventor assembly: BB3_Porte
## iProperties
Created: 2009-01
Part Number: BB3_Porte
Document SubType Name: Assembly
Designer: claivier
Author: claivier
