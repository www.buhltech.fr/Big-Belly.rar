# Autodesk Inventor assembly: BB3_Dévidoir
## iProperties
Created: 2008-11
Part Number: BB3_Dévidoir
Document SubType Name: Assembly
Designer: claivier
Author: claivier
