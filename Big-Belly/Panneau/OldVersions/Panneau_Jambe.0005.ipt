# Autodesk Inventor part: Panneau_Jambe
## iProperties
Created: 2009-01
Part Number: Panneau_Jambe
Document SubType Name: Modeling
Designer: claivier
Author: claivier
## Feature names
1. Balayage1
