# Autodesk Inventor assembly: BB3_Porte1
## iProperties
Created: 2009-01
Part Number: BB3_Porte1
Document SubType Name: Assembly
Designer: claivier
Author: claivier
