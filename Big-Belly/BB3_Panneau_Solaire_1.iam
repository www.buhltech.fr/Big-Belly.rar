# Autodesk Inventor assembly: BB3_Panneau_Solaire
## iProperties
Created: 2009-01
Part Number: BB3_Panneau_Solaire
Document SubType Name: Assembly
Designer: claivier
Author: claivier
