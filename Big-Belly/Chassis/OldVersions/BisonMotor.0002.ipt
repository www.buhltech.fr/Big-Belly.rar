# Autodesk Inventor part: BisonMotor
## iProperties
Created: 2008-11
Part Number: BisonMotor
Document SubType Name: Modeling
Designer: ETUDIANT
Author: ETUDIANT
## Feature names
1. Base1
