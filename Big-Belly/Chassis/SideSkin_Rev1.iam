# Autodesk Inventor assembly: SideSkin_Rev1
## iProperties
Created: 2008-11
Part Number: SideSkin_Rev1
Document SubType Name: Assembly
Designer: claivier
Author: claivier
