# Autodesk Inventor assembly: BB3_Dévidoir_2
## iProperties
Created: 2008-11
Part Number: BB3_Dévidoir_2
Document SubType Name: Assembly
Designer: claivier
Author: claivier
