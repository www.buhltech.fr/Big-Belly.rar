# Autodesk Inventor part: CounterDisc_Rev1
## iProperties
Created: 2008-11
Part Number: CounterDisc_Rev1
Document SubType Name: Modeling
Designer: ETUDIANT
Author: ETUDIANT
## Feature names
1. Base1
