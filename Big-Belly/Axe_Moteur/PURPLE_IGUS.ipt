# Autodesk Inventor part: PURPLE_IGUS
## iProperties
Created: 2008-11
Part Number: PURPLE_IGUS
Document SubType Name: Modeling
Designer: ETUDIANT
Author: ETUDIANT
## Feature names
1. Base1
