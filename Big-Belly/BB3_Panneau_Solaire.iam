# Autodesk Inventor assembly: BB3_Panneau_Solaire
## iProperties
Created: 2009-02
Part Number: BB3_Panneau_Solaire
Document SubType Name: Assembly
Designer: Alex_Cyril
Author: Alex_Cyril
