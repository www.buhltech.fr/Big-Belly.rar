# Autodesk Inventor assembly: Coulissant Vertical
## iProperties
Created: 2008-12
Part Number: Coulissant Vertical
Document SubType Name: Assembly
Designer: claivier
Author: claivier
