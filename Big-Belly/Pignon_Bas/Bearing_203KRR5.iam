# Autodesk Inventor assembly: Bearing_203KRR5
## iProperties
Created: 2008-11
Part Number: Bearing_203KRR5
Document SubType Name: Assembly
Designer: ETUDIANT
Author: ETUDIANT
