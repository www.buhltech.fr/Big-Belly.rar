# Autodesk Inventor assembly: BB3_Rame_Compacteur_2
## iProperties
Created: 2008-12
Part Number: BB3_Rame_Compacteur_2
Document SubType Name: Assembly
Designer: LAIVIER CYRIL
Author: LAIVIER CYRIL
