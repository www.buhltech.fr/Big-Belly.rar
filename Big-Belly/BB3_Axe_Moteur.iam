# Autodesk Inventor assembly: BB3_Axe_Moteur
## iProperties
Created: 2008-11
Part Number: BB3_Axe_Moteur
Document SubType Name: Assembly
Designer: claivier
Author: claivier
