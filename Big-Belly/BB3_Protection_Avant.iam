# Autodesk Inventor assembly: BB3_Protection_Avant
## iProperties
Created: 2009-01
Part Number: BB3_Protection_Avant
Document SubType Name: Assembly
Designer: claivier
Author: claivier
