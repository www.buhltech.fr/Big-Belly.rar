# Autodesk Inventor assembly: BB3_Dévidoir_3
## iProperties
Created: 2008-11
Part Number: BB3_Dévidoir_3
Document SubType Name: Assembly
Designer: claivier
Author: claivier
