# Autodesk Inventor assembly: BB3_Chassis1
## iProperties
Created: 2008-11
Part Number: BB3_Chassis1
Document SubType Name: Assembly
Designer: claivier
Author: claivier
